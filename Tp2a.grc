options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: ntsc_hackrf
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Usuario\Downloads\Tp2a.dat
    repeat: 'True'
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 200e3
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Video Compuesto"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    label1: Luminancia
    legend: 'False'
    name: '"Luminancia"'
    size: 4096*3
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: red
    ctrlpanel: 'True'
    grid: 'True'
    label1: Video compuesto
    legend: 'False'
    name: '"Video Compuesto"'
    size: 4096*3
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymin: '-0.5'
  states: {}

connections:
- [blocks_file_source_0, '0', low_pass_filter_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_0_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
